# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,USE_USB_OTG_FS,USE_ULPI_PHY
  c include: ..\Libraries\Include;..\Hardware\AHRS;..\Hardware\Main;..\Hardware\Initialize;..\Libraries\Include;..\Service\Application;..\System\DSP\Include;..\System\Freertos\include;..\Service\DJI_Judge;..\Libraries\include;..\System\Freertos\portable\RVDS\ARM_CM4F;..\System\CMSIS;..\Service\DJI_Judge;..\Hardware\Serial\USB_Driver\inc;..\Hardware\Serial\USB_Library\Core\inc;..\Hardware\Serial\USB_Library\Class\cdc\inc;..\Hardware\core;..\Service\LVGL\src;..\Service\LVGL\example\porting;..\Service\LVGL;..\Service\easyflash\inc;..\Service\easyflash\plugins\types\struct2json\inc;..\Service\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Hardware/Main/: main.c
  group Startup
    ../Startup/: startup_stm32f427xx.s
  group Initialize
    ../Hardware/Initialize/: delay.c led.c usart.c can.c usart1_dbus.c PID.C oled.c spi.c adc.c pwm.c user_tool.c power.c flash.c imu_bsp.c PC_usart.c buzzer.c exit.c usb_usart.c sdio.c gpio.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Freertos
    ../System/Freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../System/Freertos/portable/MemMang/: heap_4.c
    ../System/Freertos/portable/RVDS/ARM_CM4F/: port.c
  group AHRS
    ../Hardware/AHRS/: AHRS.lib AHRS.h AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c
  group CMSIS
    ../System/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group DSP
    ../System/DSP/: arm_cortexM4lf_math.lib
  group Application
    ../Service/Application/: FreeRTOS_middleware.c start_task.c user_task.c judge_task.c IMU_task.c shoot_task.c DJI_Remote_Control.c gimbal_task.c chassis_task.c Check_Task.c usb_task.c data_task.c gui_task.c
    ../Service/LVGL/: lvgl_usr_lib.c
  group help
    ../User/: help.txt
  group DJI_Judge
    ../Service/DJI_Judge/: usart_judge.c usart_judge.h Judge_Data.c Judge_Data.h Judge_CRC.c Judge_CRC.h
  group Serial
    ../Hardware/Serial/USB_Driver/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c
    ../Hardware/Serial/USB_Library/Core/src/: usbd_req.c usbd_usr.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c
    ../Hardware/Serial/USB_Library/Class/cdc/src/: usbd_cdc_core.c usbd_cdc_if_template.c
  group lvgl/example/porting
    ../Service/LVGL/example/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl/src/core
    ../Service/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../Service/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Service/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/src/font
    ../Service/LVGL/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c lv_font_montserrat_8.c lv_font_unscii_8.c
  group lvgl/src/hal
    ../Service/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../Service/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../Service/LVGL/src/widgets/: lv_bar.c lv_btn.c lv_btnmatrix.c lv_label.c lv_textarea.c lv_img.c
  group lvgl/src/extra/themes
    ../Service/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Service/LVGL/src/extra/themes/default/: lv_theme_default.c
  group lvgl/src/extra/widgets
    ../Service/LVGL/src/extra/widgets/list/: lv_list.c
    ../Service/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Service/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Service/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Service/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Service/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Service/LVGL/src/extra/widgets/win/: lv_win.c
    ../Service/LVGL/src/extra/widgets/chart/: lv_chart.c
  group lvgl/src/extra/layouts
    ../Service/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Service/LVGL/src/extra/layouts/flex/: lv_flex.c
  group lvgl/src/extra
    ../Service/LVGL/src/extra/: lv_extra.c
  group easyflash
    ../Service/easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ../Service/easyflash/port/: ef_port.c
    ../Service/easyflash/plugins/types/: ef_types.c
    ../Service/easyflash/plugins/types/struct2json/src/: cJSON.c s2j.c
  group FATFS
    ../Service/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
